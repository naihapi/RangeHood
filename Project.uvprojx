# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_LD
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\System;.\User;.\Hardware;.\Hardware\WS2812;.\Hardware\OLED;.\Hardware\KEY;.\Peripheral;.\Peripheral\GPIO;.\Peripheral\TIM;.\Software;.\Software\MyTask;.\Software\Delay;.\FreeRTOS\FreeRTOS_CORE;.\FreeRTOS\FreeRTOS_PORT;.\FreeRTOS\FreeRTOS_CORE\include;.\Software\Build;.\Software\Menu;.\Software\UI;.\Software\MyMenu;.\Software\MySystem
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_ld.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: sys.c sys.h
  group Peripheral
    ./Peripheral/GPIO/: GPIO.c GPIO.h
    ./Peripheral/TIM/: TIM.c TIM.h
  group Hardware
    ./Hardware/WS2812/: WS2812.c WS2812.h
    ./Hardware/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ./Hardware/KEY/: KEY.c KEY.h
  group Software
    ./Software/Delay/: Delay.c Delay.h
    ./Software/MyTask/: MyTask.c MyTask.h
    ./Software/Menu/: Menu.c Menu.h
    ./Software/Build/: Build.c Build.h
    ./Software/UI/: UI.c UI.h
    ./Software/MyMenu/: MyMenu.c MyMenu.h
    ./Software/MySystem/: MySystem.c MySystem.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h main.h
  group FreeRTOS_CORE
    ./FreeRTOS/FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/FreeRTOS_CORE/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS_PORT
    ./FreeRTOS/FreeRTOS_PORT/: heap_4.c port.c portmacro.h
